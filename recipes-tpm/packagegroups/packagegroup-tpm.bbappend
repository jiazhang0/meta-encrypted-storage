#
# Copyright (C) 2016 Wind River Systems, Inc.
#

RDEPENDS_packagegroup-tpm += "\
    openssl-tpm-engine \
    "
