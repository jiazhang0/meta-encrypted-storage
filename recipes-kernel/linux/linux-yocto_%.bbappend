#
# Copyright (C) 2017 Wind River Systems, Inc.
#

include linux-yocto-encrypted-storage.inc
